Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-07-31T09:52:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - IU alternativa 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 31 09:52:41 2025 * Host: DNG1464 * Database: C:\Users\maria.cardoso\AppData\Local\Temp\2cebf37a-41d4-424a-ae11-64d3ba6ea87f\11e63f9e-0040-4d07-ae68-fe1f82afdb7e\ifc * Database version: 5507 * Database creation date: Thu Jul 31 09:52:30 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 31 09:52:30 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 31 09:52:30 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Vista Principal
LongName: Vista Principal; Elevation: 0 mm

# IfcBuildingElementProxy: Texto do modelo:Subtextos (3)
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Subtextos
Type - Pset_QuantityTakeOff - Reference: Subtextos
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Width: 10 mm; Depth: 10 mm
Name (Texto do modelo:Subtextos:...) | Height (mm)
489321 | 150.684
489327 | 18.8356
489349 | 18.8356

# IfcBuildingElementProxy: Texto do modelo:Termo, Texto do modelo:Termo:489322
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Termo
Type - Pset_QuantityTakeOff - Reference: Termo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texto do modelo:Texto (10)
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Texto
Type - Pset_QuantityTakeOff - Reference: Texto
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Width: 10 mm; Depth: 10 mm
Name (Texto do modelo:Texto:...) | Height (mm)
489324
489325
489341 | 60.2738
489342 | 7.53422
489343 | 7.53422
489344 | 7.53422
489345 | 7.53422
489346 | 60.2738
489347 | 7.53422
683351

# IfcDistributionPort (31)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
4 x Port_803136
8 x Port_484219
4 x Port_690192
2 x Port_700591
2 x Port_700759
2 x Port_700982
2 x Port_701036
2 x Port_701101
3 x Port_701162
2 x Port_701286

# IfcFlowTerminal: Astra - Caixa Sifonada 10x12 cm:CS1, Astra - Caixa Sifonada 10x12 cm:CS1:803136
In: Vista Principal
Type - Material: PVC Branco (3), -
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: CS1
Material: PVC Branco
Pset_DistributionFlowElementCommon - Reference: CS1; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Caixa Sifonada 10x9 cm:CS131/V, Astra - Caixa Sifonada 10x9 cm:CS131/V:690192
In: Vista Principal
Type - Material: PVC Branco (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: CS131/V
Material: PVC Branco
Pset_DistributionFlowElementCommon - Reference: CS131/V; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Caixa Sifonada 15x15 cm:CS5, Astra - Caixa Sifonada 15x15 cm:CS5:484219
In: Vista Principal
Type - Material: ABS Cromado, PVC Branco (2), PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: CS5
Material: PVC Branco, PP Branco
Pset_DistributionFlowElementCommon - Reference: CS5; sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Articulado - SPU:SPU40 - Branco, Astra - Sifão Articulado - SPU:SPU40 - Branco:701286
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SPU40 - Branco
Pset_DistributionFlowElementCommon - Reference: SPU40 - Branco; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Duplo Sanfonado - SDU:SDU, Astra - Sifão Duplo Sanfonado - SDU:SDU:701162
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SDU
Pset_DistributionFlowElementCommon - Reference: SDU; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Sanfonado Universal - SSU:SSU - Branco (BR1), Astra - Sifão Sanfonado Universal - SSU:SSU - Branco (BR1):700759
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SSU - Branco (BR1)
Pset_DistributionFlowElementCommon - Reference: SSU - Branco (BR1); sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Sanfonado Universal - SSUM:SSUM - Branco (BR1), Astra - Sifão Sanfonado Universal - SSUM:SSUM - Branco (BR1):700982
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SSUM - Branco (BR1)
Pset_DistributionFlowElementCommon - Reference: SSUM - Branco (BR1); sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Sanfonado Universal Reduzido - SSUR:SSUR - Branco (BR1), Astra - Sifão Sanfonado Universal Reduzido - SSUR:SSUR - Branco (BR1):700591
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SSUR - Branco (BR1)
Pset_DistributionFlowElementCommon - Reference: SSUR - Branco (BR1); sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Sanfonado Universal Super - SSUS:SSUS - Branco (BR1), Astra - Sifão Sanfonado Universal Super - SSUS:SSUS - Branco (BR1):701036
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SSUS - Branco (BR1)
Pset_DistributionFlowElementCommon - Reference: SSUS - Branco (BR1); sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2

# IfcFlowTerminal: Astra - Sifão Sanfonado com Copo - SSUC:SSUC - Branco (BR1), Astra - Sifão Sanfonado com Copo - SSUC:SSUC - Branco (BR1):701101
In: Vista Principal
Type - Material: PP Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: SSUC - Branco (BR1)
Pset_DistributionFlowElementCommon - Reference: SSUC - Branco (BR1); sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
